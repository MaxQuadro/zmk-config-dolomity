## config/Kconfig.shield
```kconfig
config SHIELD_DOLOMITY_LEFT
def_bool $(shields_list_contains, Dolimity_left)

config SHIELD_DOLOMITY_RIGHT
def_bool $(shields_list_contains, Dolimity_right)
```
